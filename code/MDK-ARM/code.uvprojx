# Keil uVision project code.uvprojx, settings and files
target code (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G031C8Tx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: code +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G031xx
  c include: ../Core/Inc;../code/ads124s08;../code/pt1000;../code/pid;../code/app;../code/board_io;../code/rs485;../code/modbus_rtu;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32g031xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c iwdg.c spi.c tim.c usart.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Application/User/ADS124S08
    ../code/ads124s08/: ads124s08.c
    ../code/pt1000/: pt1000.c
    ../code/app/: pt1000_app.c temperature_control.c temperature_control_profile.c pwm_duty_test.c temperature_modbus.c
    ../code/pid/: pid.c
    ../code/board_io/: board_io.c
    ../code/rs485/: rs485.c
    ../code/modbus_rtu/: modbus_rtu_slave.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_iwdg.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_ll_dma.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
software components: CMSIS:CORE 4.3.0
